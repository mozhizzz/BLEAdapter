# Keil uVision project BLE_Adapter.uvprojx, settings and files
target BLE_Adapter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Adapter +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENUSE_HAL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_RO USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_RO BLE_STACK_CUSTOM_CONF SECURITY_MODE=JUST_WORKS
  c include: ..\..\..\Drivers\Peripherals_Drivers\inc;..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\Middlewares\ST\hal\Inc;..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\Drivers\CMSIS\Include;../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\Drivers\BSP\Common\Inc;..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\Middlewares\ST\cryptolib\inc;..\..\..\Middlewares\ST\cryptolib\inc\Common;..\..\..\Middlewares\ST\cryptolib\inc\AES;..\..\..\Middlewares\ST\BLE_Application\Profile_Central\Inc;..\..\..\Middlewares\ST\FreeRTOS\Source\include;..\..\..\Middlewares\ST\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\application;..\..\periphers;..\..\protocols;..\..\RTT
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\BlueNRG_LP.sct
  group App
    ../../application/: main.c tasks.c bluenrg_lp_it.c
  group Drivers/BSP
    ../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_mic.c bluenrg_lp_evb_spi.c
    ../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
    ../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_vtimer.c rf_driver_hal_power_manager.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c rf_driver_hal.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_gpio.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c rf_driver_hal_uart.c rf_driver_hal_uart_ex.c rf_driver_hal_iwdg.c
  group Middlewares/AES
    ../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
    ../../../Middlewares/ST/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../Middlewares/ST/hal/Src/: clock.c gp_timer.c hal_miscutil.c miscutil.c osal.c blue_unit_conversion.s context_switch.s osal_memcpy.s
  group Middlewares/NVM
    ../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Profiles
    ../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
  group Middlewares/Master_Library
    ../../../Middlewares/ST/BLE_Application/Profile_Central/library/: libmaster_library_bluenrgx.a
    ../../../Middlewares/ST/BLE_Application/Profile_Central/Profiles/ble_profile/: master_events_CB.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/ST/FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ../../../Middlewares/ST/FreeRTOS/BlueNRG/: freertos_lp.c
    ../../../Middlewares/ST/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../Middlewares/ST/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Periphers
    ../../periphers/: uart.c dma.c ble.c ble_service.c ble_event.c
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group log
    ../../application/: log.c
